# Keil uVision project eighteen.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F204EA STC
  cpu: IRAM(0-0xFF) IROM(0-0xFF8) CLOCK(35000000)
  output: eighteen +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: eighteen.c
